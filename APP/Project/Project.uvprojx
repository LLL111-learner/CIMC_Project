# Keil uVision project Project.uvprojx, settings and files
target 2026335222 (6220000::V6.22::ARMCLANG)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP +hex
  AfterMake: ./keil5_disp_size_bar.exe
  AfterMake: fromelf --bin --output=.\output\App.bin .\output\APP.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F470,__PERF_COUNTER_CFG_USE_SYSTICK_WRAPPER__
  c include: ..\HeaderFiles\common;..\Protocol;..\Function;..\Library\GD32F4xx_standard_peripheral\Include;..\HeaderFiles\User;..\CMSIS\CMSIS_6.2.0\CMSIS\Core\Include;..\CMSIS\CMSIS_6.2.0\CMSIS\Core\Include\a-profile;..\CMSIS\CMSIS_6.2.0\CMSIS\Core\Include\m-profile;..\CMSIS\CMSIS_6.2.0\CMSIS\Core\Include\r-profile;..\CMSIS\CMSIS;..\CMSIS\CMSIS\GD\GD32F4xx\Include;..\Driver\bsp;..\Driver\led;..\Driver\key;..\Driver\uart;..\Driver\oled;..\Driver\gd30ad3344;..\Driver\adc;..\Driver\dac;..\Driver\rtc;..\Driver\power;..\Library\Third_Party\perf_counter-2.5.4
  library: MicroLIB
  memory RVCT4: ROM 0x8011000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\App_F470.sct
  group User
    ../User/src/: gd32f4xx_it.c main.c systick.c
  group Driver
    ../Driver/bsp/: bsp_system.h
    ../Driver/led/: led_driver.c
    ../Driver/key/: key_driver.c
    ../Driver/uart/: uart_driver.c
    ../Driver/oled/: oled_driver.c oled.c
    ../Driver/gd30ad3344/: gd30ad3344_driver.c gd30ad3344.c
    ../Driver/adc/: adc_driver.c
    ../Driver/dac/: dac_driver.c
    ../Driver/rtc/: rtc_driver.c
    ../Driver/power/: power_driver.c
  group HeaderFiles
    ../HeaderFiles/common/: bl_param.h bl_partition.h
  group Protocol
    ../Protocol/: system_protocol.c
  group Function
    ../Function/: led_app.c oled_app.c scheduler.c usart_app.c rtc_app.c adc_app.c alarm_app.c data_app.c param_app.c system_app.c
  group Library
    ../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
    ../Library/Third_Party/perf_counter-2.5.4/: perf_counter.c perfc_port_default.c systick_wrapper_ual.s
  group Startup
    ../Startup/: startup_gd32f450_470.s
  group CMSIS
    ../CMSIS/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
